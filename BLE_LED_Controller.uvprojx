# Keil uVision project BLE_LED_Controller.uvprojx, settings and files
target BLE_LED_Controller (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.pdsc
  cpu: CPUTYPE("Cortex-M0")
  output: BLE_LED_Controller
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTARGET_MCU_NRF51822 -DTARGET_NRF5 --preinclude=mbed_config.h --split_sections -DTARGET_MCU_NRF51822_UNIFIED -DTARGET_MCU_NRF51_32K -D__ASSERT_MSG -DTARGET_MCU_NORDIC_32K -DTARGET_NRF51822 --no_rtti -DS130 -DCMSIS_VECTAB_VIRTUAL_HEADER_FILE=\"cmsis_nvic.h\" -DDEVICE_PORTINOUT=1 -DTARGET_MCU_NRF51_32K_UNIFIED -DDEVICE_SERIAL_FC=1 -DSOFTDEVICE_PRESENT -DDEVICE_PWMOUT=1 -DDEVICE_I2C_ASYNCH=1 -DTARGET_FF_ARDUINO -c -DTARGET_NORDIC -DCMSIS_VECTAB_VIRTUAL -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DTARGET_RELEASE -DTARGET_LIKE_MBED -DTARGET_MCU_NRF51_UNIFIED -DTARGET_LIKE_CORTEX_M0 -DARM_MATH_CM0 -DDEVICE_ANALOGIN=1 -DTARGET_NRF51_DK -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DTARGET_MCU_NRF51 --cpu=Cortex-M0 -DDEVICE_I2C=1 -DBLE_STACK_SUPPORT_REQD -DTARGET_CORTEX -DDEVICE_LOWPOWERTIMER=1 -DMBED_BUILD_TIMESTAMP=1519063926.03 -DTOOLCHAIN_ARM -D__CORTEX_M0 -DNRF51 -DTOOLCHAIN_ARM_STD --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DNO_SYSTICK -DDEVICE_SERIAL_ASYNCH=1 --gnu -DMBED_TICKLESS --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SERIAL=1 -DTARGET_M0 -DDEVICE_INTERRUPTIN=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DFEATURE_BLE=1 -D__MBED_CMSIS_RTOS_CM -DTARGET_SDK11
  c include: .; BLE_API; BLE_API/common; BLE_API/public; BLE_API/services; nRF51822; nRF51822/btle; nRF51822/btle/custom; nRF51822/common; nRF51822/nordic; nRF51822/nordic/app_common; nRF51822/nordic/ble; nRF51822/nordic/ble/ble_services; nRF51822/nordic/bootloader_dfu; nRF51822/nordic/nrf-sdk; nRF51822/nordic/nrf-sdk/app_common; nRF51822/nordic/nrf-sdk/ble; nRF51822/nordic/nrf-sdk/ble/ble_services; nRF51822/nordic/nrf-sdk/ble/device_manager; nRF51822/nordic/nrf-sdk/bootloader_dfu; nRF51822/nordic/nrf-sdk/s110; nRF51822/nordic/nrf-sdk/sd_common; mbed/.; mbed/TARGET_NRF51_DK; mbed/TARGET_NRF51_DK/TARGET_NORDIC; mbed/TARGET_NRF51_DK/TOOLCHAIN_ARM_STD;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M0,-DTARGET_MCU_NRF51_32K,-DTARGET_MCU_NRF51822,-DTARGET_MCU_NORDIC_32K,-DSOFTDEVICE_PRESENT,-DNRF51,-DNO_SYSTICK,-DBLE_STACK_SUPPORT_REQD,-DTARGET_NRF51822,-DARM_MATH_CM0,-D__MBED_CMSIS_RTOS_CM,-DCMSIS_VECTAB_VIRTUAL_HEADER_FILE="cmsis_nvic.h",-DCMSIS_VECTAB_VIRTUAL,-D__CMSIS_RTOS,-DMBED_TICKLESS,-DS130
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_NRF51_DK/TOOLCHAIN_ARM_STD/nRF51822.sct
  link misc: --show_full_path
  group BLE_API
    BLE_API/services/: BatteryService.h DeviceInformationService.h DFUService.cpp DFUService.h HealthThermometerService.h HeartRateService.h UARTService.cpp UARTService.h URIBeaconConfigService.h
    BLE_API/common/: blecommon.h BLEDevice.cpp BLEDeviceInstanceBase.h GapAdvertisingData.cpp GapAdvertisingParams.cpp GattService.cpp UUID.cpp
    BLE_API/public/: BLEDevice.h CallChainOfFunctionPointersWithContext.h FunctionPointerWithContext.h Gap.h GapAdvertisingData.h GapAdvertisingParams.h GapEvents.h GattAttribute.h GattCharacteristic.h GattCharacteristicWriteCBParams.h GattServer.h GattServerEvents.h GattService.h UUID.h
  group BLE_LED_Controller
    ./: main.cpp mbed_config.h
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h toolchain.h us_ticker_api.h wait_api.h
    mbed/TARGET_NRF51_DK/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o mbed.ar retarget.o startup_nRF51822.o sys.o system_nrf51822.o
    mbed/TARGET_NRF51_DK/: cmsis.h cmsis_nvic.h compiler_abstraction.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h nordic_global.h nrf51.h nrf51822.h nrf51_bitfields.h system_nrf51822.h
  group nRF51822
    nRF51822/common/: ansi_escape.h assertion.h binary.h ble_error.h common.h compiler.h
    nRF51822/nordic/nrf-sdk/sd_common/: ant_stack_handler_types.h app_util_platform.h ble_stack_handler_types.h softdevice_handler.h
    nRF51822/nordic/nrf-sdk/app_common/: app_button.h app_error.h app_fifo.h app_gpiote.h app_scheduler.h app_timer.h app_trace.h app_uart.h app_util.h crc16.h hal_transport.h hci_mem_pool.h hci_mem_pool_internal.h hci_slip.h hci_transport.h pstorage.h
    nRF51822/nordic/app_common/: app_gpiote.c app_scheduler.c crc16.cpp hci_mem_pool.c pstorage.cpp
    nRF51822/nordic/nrf-sdk/s110/: ble.h ble_err.h ble_gap.h ble_gatt.h ble_gattc.h ble_gatts.h ble_hci.h ble_l2cap.h ble_ranges.h ble_types.h nrf_error.h nrf_error_sdm.h nrf_error_soc.h nrf_mbr.h nrf_sdm.h nrf_soc.h nrf_svc.h softdevice_assert.h
    nRF51822/nordic/ble/: ble_advdata.cpp ble_advdata_parser.cpp ble_bondmngr.cpp ble_conn_params.cpp ble_debug_assert_handler.cpp ble_error_log.cpp
    nRF51822/nordic/nrf-sdk/ble/: ble_advdata.h ble_advdata_parser.h ble_central_bondmngr.h ble_conn_params.h ble_date_time.h ble_db_discovery.h ble_debug_assert_handler.h ble_dtm.h ble_error_log.h ble_flash.h ble_racp.h ble_radio_notification.h ble_sensorsim.h
    nRF51822/nordic/nrf-sdk/ble/ble_services/: ble_ans_c.h ble_bas.h ble_bas_c.h ble_bps.h ble_cscs.h ble_dfu.h ble_dis.h ble_gls.h ble_gls_db.h ble_hids.h ble_hrs.h ble_hrs_c.h ble_hts.h ble_ias.h ble_ias_c.h ble_lls.h ble_rscs.h ble_sc_ctrlpt.h ble_sensor_location.h ble_srv_common.h ble_tps.h
    nRF51822/nordic/: ble_bondmngr_cfg.h nordic_global.h pstorage_platform.h softdevice_handler.cpp
    nRF51822/nordic/ble/ble_services/: ble_srv_common.cpp
    nRF51822/nordic/nrf-sdk/bootloader_dfu/: bootloader_types.h bootloader_util.h dfu_app_handler.h
    nRF51822/nordic/bootloader_dfu/: bootloader_util_arm.c dfu_app_handler.c
    nRF51822/btle/: btle.cpp btle.h btle_advertising.cpp btle_advertising.h btle_gap.cpp btle_gap.h
    nRF51822/btle/custom/: custom_helper.cpp custom_helper.h
    nRF51822/nordic/nrf-sdk/ble/device_manager/: device_manager.h
    nRF51822/nordic/nrf-sdk/: nordic_common.h nrf_assert.h nrf_delay.h nrf_ecb.h nrf_gpio.h nrf_nvmc.h nrf_temp.h system_nrf51.h
    nRF51822/: nRF51822n.cpp nRF51822n.h nRF51Gap.cpp nRF51Gap.h nRF51GattServer.cpp nRF51GattServer.h projectconfig.h
